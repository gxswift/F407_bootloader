# Keil uVision project F407_Bootloader.uvprojx, settings and files
target F407_Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_Bootloader +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Drivers\STM32F4xx_HAL_Driver\Inc;..\FatFs\src;..\FatFs\src\drivers;..\USB\Class\MSC\Inc;..\USB\Core\Inc;..\Drivers\CMSIS;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Inc;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group HAL_Library
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rcc_ex.c
  group USB_Library
    ../USB/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../USB/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Fatfs
    ../FatFs/src/drivers/: usbh_diskio.c
    ../FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group User
    ../Src/: main.c stm32f4xx_assert.c stm32f4xx_hal_msp.c usbh_conf.c stm32f4xx_it.c adcii_24.c
